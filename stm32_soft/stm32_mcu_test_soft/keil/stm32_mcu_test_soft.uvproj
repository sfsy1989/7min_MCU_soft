# Keil uVision project stm32_mcu_test_soft.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32_mcu_test_soft +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c include: ..\STM32F0_Discovery_Library\STM32F0xx_StdPeriph_Driver\inc;..\STM32F0_Discovery_Library
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group user
    ../: main.c uart.c user_i2c.c
  group lib
    ../STM32F0_Discovery_Library/: system_stm32f0xx.c stm32f0xx_it.c
    ../STM32F0_Discovery_Library/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_rcc.c stm32f0xx_usart.c stm32f0xx_adc.c stm32f0xx_misc.c stm32f0xx_tim.c
    ../STM32F0_Discovery_Library/CMSIS/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
