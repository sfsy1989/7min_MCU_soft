# Keil uVision project stm32_7min_mcu_soft.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F030F4 STMicroelectronics
  cpu: IROM(0x08000000,0x4000) IRAM(0x20000000,0x1000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: stm32_7min_mcu_soft +hex
  c flags: Optim=1 oTime=1 OneElfS=1 wLevel=2
  c include: ..\user;..\STM32F0_Discovery_Library\STM32F0xx_StdPeriph_Driver\inc;..\STM32F0_Discovery_Library
  memory RVCT4: ROM 0x8000000 size 0x4000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group user
    ../user/: main.c user_gpio.c user_keypress.c user_power_measure.c user_slave_i2c.c user_temperature_measure.c user_timer.c user_ir.c uart.c
  group stdlib
    ../STM32F0_Discovery_Library/CMSIS/ST/STM32F0xx/Source/Templates/arm/: startup_stm32f0xx.s
    ../STM32F0_Discovery_Library/STM32F0xx_StdPeriph_Driver/src/: stm32f0xx_adc.c stm32f0xx_crc.c stm32f0xx_dac.c stm32f0xx_gpio.c stm32f0xx_i2c.c stm32f0xx_iwdg.c stm32f0xx_rcc.c stm32f0xx_rtc.c stm32f0xx_tim.c stm32f0xx_wwdg.c stm32f0xx_exti.c stm32f0xx_misc.c stm32f0xx_syscfg.c stm32f0xx_dma.c stm32f0xx_usart.c
    ../STM32F0_Discovery_Library/: stm32f0xx_it.c system_stm32f0xx.c
